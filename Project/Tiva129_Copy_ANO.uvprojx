# Keil uVision project Tiva129_Copy_ANO.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C129ENCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tiva129_Copy_ANO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C129ENCPDT   TARGET_IS_TM4C129_RA1
  c include: ..\Code;..\Code\Tivaware;..\Code\Tivaware\CMSIS;..\Code\Tivaware\CMSIS\CORE;..\Code\Tivaware\DSPLIB;..\Code\Tivaware\DSPLIB\Include;..\Code\Tivaware\TivaWareLIB;..\Code\Tivaware\TivaWareLIB\driverlib;..\Code\Tivaware\TivaWareLIB\inc;..\Code\Tivaware\TivaWareLIB\utils;..\Code\BSP\SYSTEM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../Code/APP/ANO_DT/: Ano_DT.c Ano_DT.h ANO_DT_User_Settings.h
    ../Code/APP/Task_Scheduler/: Task_Scheduler.c Task_Scheduler.h
    ../Code/APP/Triz_FlyCtrl/: Triz_AltCtrl.c Triz_AltCtrl.h Triz_AttCtrl.c Triz_AttCtrl.h Triz_FlyCtrl.c Triz_FlyCtrl.h Triz_LocCtrl.c Triz_LocCtrl.h Triz_MotorCtrl.c Triz_MotorCtrl.h
    ../Code/APP/Triz_FlyData/: Triz_Config.h Triz_FcData.c Triz_FcData.h Triz_FcParameter.c Triz_FcParameter.h Triz_FlightDataCal.c Triz_FlightDataCal.h Triz_MagProcess.c Triz_MagProcess.h Triz_Power.c Triz_Power.h
    ../Code/APP/: App_include.h
  group BSP
    ../Code/BSP/Drv_adc/: Drv_adc.c Drv_adc.h
    ../Code/BSP/Drv_ak8975/: Drv_ak8975.c Drv_ak8975.h
    ../Code/BSP/Drv_camara/: Drv_camara.c Drv_camara.h
    ../Code/BSP/Drv_capture/: Drv_RC.c Drv_RC.h
    ../Code/BSP/Drv_icm20602/: Drv_icm20602.c Drv_icm20602.h
    ../Code/BSP/Drv_led/: Drv_led.c Drv_led.h
    ../Code/BSP/Drv_spi/: Drv_spi.c Drv_spi.h
    ../Code/BSP/Drv_pwm/: Drv_pwm.c Drv_pwm.h
    ../Code/BSP/Drv_spl06/: Drv_spl06.c Drv_spl06.h
    ../Code/BSP/Drv_time/: Drv_time.c Drv_time.h
    ../Code/BSP/Drv_us100/: Drv_us100.c Drv_us100.h
    ../Code/BSP/Drv_usart/: Drv_uart.c Drv_uart.h Drv_uart_User_Setting.h
    ../Code/BSP/: Drv_include.h
  group Tivaware
    ../Code/Tivaware/TivaWareLIB/src/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group USER
    ../Code/Tivaware/STARTUP/: startup_rvmdk.S
    ../Code/Tivaware/: system_TM4C12x.c
    ../Code/APP/: main.c
  group Common
    ../Code/Common/: Ano_Filter.c Ano_Filter.h Ano_Imu.c Ano_Imu.h Ano_Math.c Ano_Math.h Ano_MotionCal.c Ano_MotionCal.h Ano_Navigate.c Ano_Navigate.h Ano_Pid.c Ano_Pid.h Com_include.h
